# IAR project r006.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: r006.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2364 NXP LPC2364
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 1
  ICCARM.CCIncludePath2: board\; app\; module\; uip\; ; ws\
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: r006.hex
  ILINK.IlinkIcfFile: config\lpc2364_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: !.doc init.c main.c
    app/: includes.h
    arm/: LPC2300.s
    Release/List/: r006.map
  group app
    app/: clock-arch.c
    uip/: timer.c
  group LinkMan
    ./: lnkmngr_u3.c
  group memorys
    ./: DExS_mem_struct.c flash_data.c memutil.c ramdata.c
  group modbus
    ./: crc16.c modbus.c
  group uarts
    module/: uart.c
    ./: uart1rs485.c
  group uip
    uip/: LPC23xx_enet.c tcp_ctrl.c tcpip_uart_bridge.c uip.c uip_arp.c
  group ws
    ws/: base64.c sha1.c uip_app_dispatch.c websocket_server.c ws_uart_bridge.c
