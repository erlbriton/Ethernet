# IAR project Backup of mtcp.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpannl8n.h
  General.OGChipSelectEditMenu: LPC2364 NXP LPC2364
  ICCARM.CCDefines: IAR_LPC_P2378_SK
  ICCARM.CCIncludePath2: board\; app\; module\
  XLINK.XclFile: D:\Project\Projects\SMFCB\DExSys\LPC\r006\config\LPC2364_Flash.xcl
  group (top)
    ./: bastypes.h crc16.c lnkmngr.c lnkmngr.h main.c modbus.c ramdata.c uart0usb.c uart2rs485.c
    $EW_DIR$/arm/src/lib/: cstartup.s79
    app/: includes.h
    module/: uart.c uart.h
