# IAR project Backup of r006.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: LPC2364 NXP LPC2364
  ICCARM.CCIncludePath2: board\; app\; module\; fs\; 
  XLINK.XclFile: D:\Project\Projects\SMFCB\Options\iCM_DA\fw\lpc001\config\LPC2364_Flash.xcl
  group (top)
    ./: aout.c crc16.c dio.c flash_data.c lnkmngr.c main.c memutil.c modbus.c qrc.c ramdata.c uart0rs485.c uart1rs485.c uart2rs485.c
    fs/: asmfunc.s79
    arm/: cstartup.s79
    app/: includes.h
    Release/List/: r006.map
    module/: uart.c
